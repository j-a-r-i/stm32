# Keil uVision project TempMeasure.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TempMeasure
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;..\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ./src/: config.c main.c nexa.c out.c queue.c
  group Drivers
    ../drivers/: ds1820.c
  group stm32
    ../STM32F0xx_StdPeriph_Lib_V1.3.1/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_syscfg.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
